# IAR project VermaSirProject.ewp, settings and files
configuration VermaSirProject (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030x6
  ICCARM.IExtraOptions: /*; @Heading:; @Description:; @Needs:; Author : Harsh Dixit; */
  ICCARM.CCIncludePath2: ..\Core\Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ..\Core\Src\GSMTraffic\Inc; ..\Core\Src\MC66_GSM\Inc; ..\Core\Src\AppsTimers\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VermaSirProject.hex
  ILINK.IlinkOutputFile: VermaSirProject.out
  ILINK.IlinkIcfFile: stm32f030x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030x6.s
  group Application/User/Core
    ../Core/Src/: adc.c flash.c gpio.c main.c stm32f0xx_hal_msp.c stm32f0xx_it.c tim.c usart.c
  group Application/User/Core/AppGSMTraffic
    ../Core/Src/GSMTraffic/Src/: AppsGsmTraffic.c
  group Application/User/Core/AppsTimer
    ../Core/Src/AppsTimers/Src/: AppsTimer.c
  group Application/User/Core/Common
    ../Core/Src/: AppControls.c
  group Application/User/Core/M66GSM
    ../Core/Src/MC66_GSM/Src/: mc66gsm.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
